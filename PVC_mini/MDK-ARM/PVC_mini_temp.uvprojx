# Keil uVision project PVC_mini_temp.uvprojx, settings and files
target PVC_mini_temp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F767NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: PVC_mini_temp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\lib_stm32f7_ov5653
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xc0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: PVC_mini_temp\PVC_mini_temp.sct
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usbd_desc.c usbd_conf.c usb_device.c stm32f7xx_hal_msp.c main.c stm32f7xx_it.c usbd_cdc_if.c test.c is42s16160g-6bl.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_tim.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dsi.c stm32f7xx_ll_usb.c stm32f7xx_hal_cortex.c stm32f7xx_hal_eth.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2s.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_pcd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal.c
  group lib_stm32F4_ov5653
    ../lib_stm32f7_ov5653/: lib_stm32f7_ov5653.c lib_stm32f7_ov5653.h
software components: CMSIS:CORE 5.0.1
